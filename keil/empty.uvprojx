# Keil uVision project empty.uvprojx, settings and files
target empty (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: empty +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __MSP432P401R__
  c include: ../../../../../../source;../../../../../../source/third_party/CMSIS/Include/;..\..\empty;..\user\led;..\ti;..\user\key;..\sys;D:\Keil 5--MDK\ARM\ARMCC\include;..\user\timer;..\obj
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source
    ./: startup_msp432p401r_uvision.s
    ../user/: main.c
    ../ti/: system_msp432p401r.c
    ../user/led/: led.c
    ../user/key/: key.c
    ../sys/: delay.c baudrate_calculate.c sysinit.c usart.c timA.c tim32.c
  group Library
    ../../msp432_driverlib_3_21_00_05/driverlib/MSP432P4xx/keil/: msp432p4xx_driverlib.lib
software components: CMSIS:CORE 4.3.0
